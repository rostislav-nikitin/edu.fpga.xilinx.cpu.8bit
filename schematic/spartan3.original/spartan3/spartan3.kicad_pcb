# Repository rostislav-nikitin/edu.fpga.xilinx.cpu.8bit

File README.md:

# edu.fpga.xilinx.cpu.8bit
8 bit CPU

## KiCad design schematic/spartan3.original/spartan3/spartan3.kicad_pcb

Schematic: spartan3.kicad_sch

Parts (part):
C_clk_0: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C_clk_1: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C_clk_out_0: 15pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C_eeprom_vcc_0: 104; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C_pwr_aux_0, C_pwr_aux_1: 100uF; CP_Elec_6.3x5.4
C_pwr_vcc_0: 100uF; CP_Elec_6.3x5.4
C_pwr_vcc_core_0, C_pwr_vcc_core_1: 100uF; CP_Elec_6.3x5.4
D_in_acc_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_acc_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_bus1_one_0, D_in_bus1_ps_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_clk_manual_0: LED yellow 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_iar_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_iar_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_ir_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_ir_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_is_bus1_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_is_clk_external_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_is_clk_high_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_is_clk_low_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_is_clk_manual_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_is_clk_veryhigh_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_manual_input_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_none_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_r0_r_0, D_in_r1_r_0, D_in_r2_r_0, D_in_r3_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_r0_w_0, D_in_r1_w_0, D_in_r2_w_0, D_in_r3_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_ram_a_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_ram_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_ram_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_read_reg_en_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_temp_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_in_write_reg_en_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_acc_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_acc_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_bus1_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_can_read_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_can_write_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_clk_internal_0: LED yellow 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_clkc_0: LED yellow 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_clkr_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_clkw_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_flags_C_out_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_flags_eq_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_flags_gt_0: LED yellow 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_flags_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_flags_z_0: LED blue 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_iar_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_iar_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_ir_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_is_bus1_w_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_r0_r_0, D_out_r1_r_0, D_out_r2_r_0, D_out_r3_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_r0_w_0, D_out_r1_w_0, D_out_r2_w_0, D_out_r3_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_ram_a_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_ram_r_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_ram_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_s1_0, D_out_s2_0, D_out_s3_0, D_out_s4_0, D_out_s5_0, D_out_s6_0: LED orange 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_sysbus_0, D_out_sysbus_1, D_out_sysbus_2, D_out_sysbus_3, D_out_sysbus_4, D_out_sysbus_5, D_out_sysbus_6, D_out_sysbus_7: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_out_temp_w_0: LED red 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D_vcc_0: LED green 2.0V/20mA; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F_pwr_0: Fuse 3.3V / 2A; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
JP_SPI_Direct_PRG_0: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
J_DONE_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_DOUT_BUSY_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_FPGA_B_0, J_FPGA_B_1, J_FPGA_B_2, J_FPGA_B_3: Conn_01x36_Male; PinHeader_1x36_P2.54mm_Vertical
J_GND_0: Conn_01x01_Male; PinHeader_1x01_P2.54mm_Vertical
J_INIT_B_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_OUT_USART1_TX_0: Conn_01x01_Male; PinHeader_1x01_P2.54mm_Vertical
J_P29_0, J_P31_0, J_P36_0, J_P48_0, J_P78_0, J_P84_0, J_P101_0, J_P107_0, J_P111_0, J_P114_0, J_P128_0, J_P129_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_PROG_B_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_TCK_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_TDI_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_TDO_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_TMS_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_VCC_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_VCC_aux_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_VCC_core_0: Conn_01x01_Male; SolderWirePad_1x01_SMD_1x2mm
J_clk_0: Conn_01x01_Male; PinHeader_1x01_P2.54mm_Vertical
J_pwr_0: USB_A; USB_A_Molex_105057_Vertical
P_JTAG_FLASH_0: Xilinx_JTAG; IDC-Header_2x07_P2.54mm_Vertical
P_JTAG_FPGA_0: Xilinx_JTAG; IDC-Header_2x07_P2.54mm_Vertical
R_HSWAP_EN_0: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_JTAG_TCK_0: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_JTAG_TDI_0: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_JTAG_TDO_0: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_JTAG_TMS_0: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_M_0: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_PROG_B_0: 820R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_VS_0, R_VS_1, R_VS_2: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R__eeprom_dq1_0: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_clk_oe_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_clk_out_0: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_acc_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_acc_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_bus1_one_0, R_d_in_bus1_ps_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_clk_manual_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_iar_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_iar_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_ir_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_ir_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_is_bus1_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_is_clk_external_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_is_clk_high_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_is_clk_low_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_is_clk_manual_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_is_clk_veryhigh_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_manual_input_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_none_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_r0_r_0, R_d_in_r0_w_0, R_d_in_r1_r_0, R_d_in_r1_w_0, R_d_in_r2_r_0, R_d_in_r2_w_0, R_d_in_r3_r_0, R_d_in_r3_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_ram_a_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_ram_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_ram_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_read_reg_en_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_temp_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_d_in_write_reg_en_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_eeprom_hold_0: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_eeprom_s_0: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_eeprom_spi_clk_pulldown_0: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_eeprom_spi_clk_pullup_0: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_eeprom_w_0: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_acc_r_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_acc_w_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_bus1_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_clk_manual_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_iar_r_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_iar_w_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_ir_r_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_ir_w_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_is_bus1_w_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_is_clk_external_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_is_clk_high_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_is_clk_low_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_is_clk_manual_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_is_clk_veryhigh_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_manual_input_o_0, R_in_manual_input_o_1, R_in_manual_input_o_2, R_in_manual_input_o_3, R_in_manual_input_o_4, R_in_manual_input_o_5, R_in_manual_input_o_6, R_in_manual_input_o_7: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_manual_input_r_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_r0_r_0, R_in_r0_w_0, R_in_r1_r_0, R_in_r1_w_0, R_in_r2_r_0, R_in_r2_w_0, R_in_r3_r_0, R_in_r3_w_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_ram_a_w_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_ram_r_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_ram_w_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_read_reg_en_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_temp_w_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_in_write_reg_en_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_acc_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_acc_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_bus1_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_can_read_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_can_write_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_clk_internal_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_clkc_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_clkr_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_clkw_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_flags_C_out_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_flags_eq_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_flags_gt_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_flags_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_flags_z_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_iar_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_iar_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_ir_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_is_bus1_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_r0_r_0, R_out_r0_w_0, R_out_r1_r_0, R_out_r1_w_0, R_out_r2_r_0, R_out_r2_w_0, R_out_r3_r_0, R_out_r3_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_ram_a_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_ram_r_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_ram_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_s1_0, R_out_s2_0, R_out_s3_0, R_out_s4_0, R_out_s5_0, R_out_s6_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_sysbus_0, R_out_sysbus_1, R_out_sysbus_2, R_out_sysbus_3, R_out_sysbus_4, R_out_sysbus_5, R_out_sysbus_6, R_out_sysbus_7: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_out_temp_w_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_reset_0: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R_vcc_0: 68R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW_in_acc_w_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_bus1_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_clk_manual_0: SW_Push; SPST_Square
SW_in_iar_w_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_ir_w_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_is_bus1_w_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_manual_input_o_0, SW_in_manual_input_o_1, SW_in_manual_input_o_2, SW_in_manual_input_o_3, SW_in_manual_input_o_4, SW_in_manual_input_o_5, SW_in_manual_input_o_6, SW_in_manual_input_o_7: SW_SPDT; SW_SPDT_Small
SW_in_r0_w_0, SW_in_r1_w_0, SW_in_r2_w_0, SW_in_r3_w_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_ram_a_w_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_ram_w_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_read_reg_en_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_temp_w_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_in_write_reg_en_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_pwr_0: SW_DPDT_x2; Tactile_6PIN_SPDT_8.5x8.5mm
SW_read_register_0: SW_Rotary12; SR26 1-1-12P
SW_reset_0: SW_Push; SW_PUSH_6mm_H9.5mm
U1_clk_select_0: SPFT_Sliding_Switch-dynacore; SW_Sliding_5Pos
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
Connections:
CCLK: J_FPGA_B_2.35, P_JTAG_FLASH_0.6 (TCK), R_eeprom_spi_clk_pulldown_0.1, R_eeprom_spi_clk_pullup_0.1, U_FPGA_0.71 (CCLK), U_eeprom_0.6 (C)
D0_DIN: J_FPGA_B_2.27, P_JTAG_FLASH_0.8 (TDO), R__eeprom_dq1_0.1, U_FPGA_0.63 (D0_DIN)
DONE: J_DONE_0.1, J_FPGA_B_2.36, U_FPGA_0.72 (DONE)
DOUT_BUSY: D_out_sysbus_5.2 (A), J_DOUT_BUSY_0.1, J_FPGA_B_2.7, U_FPGA_0.43 (DOUT_BUSY)
GND: C_clk_0.2, C_clk_1.2, C_clk_out_0.2, C_eeprom_vcc_0.1, C_pwr_aux_0.2, C_pwr_aux_1.2, C_pwr_vcc_0.2, C_pwr_vcc_core_0.2, C_pwr_vcc_core_1.2, J_FPGA_B_2.21, J_FPGA_B_2.24, J_GND_0.1, J_pwr_0.4 (GND), P_JTAG_FLASH_0.1 (GND), P_JTAG_FLASH_0.3 (GND), P_JTAG_FLASH_0.5 (GND), P_JTAG_FLASH_0.7 (GND), P_JTAG_FLASH_0.9 (GND), P_JTAG_FLASH_0.11 (GND), P_JTAG_FLASH_0.13 (GND), P_JTAG_FPGA_0.1 (GND), P_JTAG_FPGA_0.3 (GND), P_JTAG_FPGA_0.5 (GND), P_JTAG_FPGA_0.7 (GND), P_JTAG_FPGA_0.9 (GND), P_JTAG_FPGA_0.11 (GND), P_JTAG_FPGA_0.13 (GND), R_PROG_B_0.1, R_d_in_bus1_ps_0.1, R_eeprom_spi_clk_pulldown_0.2, R_out_acc_r_0.2, R_out_acc_w_0.2, R_out_bus1_0.2, R_out_can_read_0.2, R_out_can_write_0.2, R_out_clk_internal_0.2, R_out_clkc_0.2, R_out_clkr_0.2, R_out_clkw_0.2, R_out_flags_C_out_0.2, R_out_flags_eq_0.2, R_out_flags_gt_0.2, R_out_flags_w_0.2, R_out_flags_z_0.2, R_out_iar_r_0.2, R_out_iar_w_0.2, R_out_ir_w_0.2, R_out_is_bus1_w_0.2, R_out_r0_r_0.2, R_out_r0_w_0.2, R_out_r1_r_0.2, R_out_r1_w_0.2, R_out_r2_r_0.2, R_out_r2_w_0.2, R_out_r3_r_0.2, R_out_r3_w_0.2, R_out_ram_a_w_0.2, R_out_ram_r_0.2, R_out_ram_w_0.2, R_out_s1_0.2, R_out_s2_0.2, R_out_s3_0.2, R_out_s4_0.2, R_out_s5_0.2, R_out_s6_0.2, R_out_sysbus_0.2, R_out_sysbus_1.2, R_out_sysbus_2.2, R_out_sysbus_3.2, R_out_sysbus_4.2, R_out_sysbus_5.2, R_out_sysbus_6.2, R_out_sysbus_7.2, R_out_temp_w_0.2, R_vcc_0.2, SW_in_acc_w_0.4 (A), SW_in_bus1_0.1 (A), SW_in_clk_manual_0.2, SW_in_iar_w_0.4 (A), SW_in_ir_w_0.4 (A)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; also elsewhere on the board
HSWAP_EN: J_FPGA_B_0.35, R_HSWAP_EN_0.1, U_FPGA_0.143 (HSWAP_EN)
INIT_B: D_out_sysbus_4.2 (A), J_FPGA_B_2.4, J_INIT_B_0.1, U_FPGA_0.40 (INIT_B)
M0: J_FPGA_B_2.26, R_M_0.1, U_FPGA_0.62 (M0)
unnamed: C_clk_out_0.1, R_clk_out_0.1, X_clk_0.3 (OUT)
unnamed: D_in_acc_r_0.2 (A), R_d_in_acc_r_0.2
unnamed: D_in_acc_w_0.2 (A), R_d_in_acc_w_0.2
unnamed: D_in_bus1_one_0.2 (A), R_d_in_bus1_one_0.1
unnamed: D_in_bus1_ps_0.1 (K), R_d_in_bus1_ps_0.2
unnamed: D_in_clk_manual_0.2 (A), R_d_in_clk_manual_0.2
unnamed: D_in_iar_r_0.2 (A), R_d_in_iar_r_0.2
unnamed: D_in_iar_w_0.2 (A), R_d_in_iar_w_0.2
unnamed: D_in_ir_r_0.2 (A), R_d_in_ir_r_0.2
unnamed: D_in_ir_w_0.2 (A), R_d_in_ir_w_0.2
unnamed: D_in_is_bus1_w_0.2 (A), R_d_in_is_bus1_w_0.2
unnamed: D_in_is_clk_external_0.2 (A), R_d_in_is_clk_external_0.2
unnamed: D_in_is_clk_high_0.2 (A), R_d_in_is_clk_high_0.2
unnamed: D_in_is_clk_low_0.2 (A), R_d_in_is_clk_low_0.2
unnamed: D_in_is_clk_manual_0.2 (A), R_d_in_is_clk_manual_0.2
unnamed: D_in_is_clk_veryhigh_0.2 (A), R_d_in_is_clk_veryhigh_0.2
unnamed: D_in_manual_input_r_0.2 (A), R_d_in_manual_input_r_0.2
unnamed: D_in_none_r_0.1 (K), SW_read_register_0.4
unnamed: D_in_none_r_0.2 (A), R_d_in_none_r_0.2
unnamed: D_in_r0_r_0.2 (A), R_d_in_r0_r_0.2
unnamed: D_in_r0_w_0.2 (A), R_d_in_r0_w_0.2
unnamed: D_in_r1_r_0.2 (A), R_d_in_r1_r_0.2
unnamed: D_in_r1_w_0.2 (A), R_d_in_r1_w_0.2
unnamed: D_in_r2_r_0.2 (A), R_d_in_r2_r_0.2
unnamed: D_in_r2_w_0.2 (A), R_d_in_r2_w_0.2
unnamed: D_in_r3_r_0.2 (A), R_d_in_r3_r_0.2
unnamed: D_in_r3_w_0.2 (A), R_d_in_r3_w_0.2
unnamed: D_in_ram_a_w_0.2 (A), R_d_in_ram_a_w_0.2
unnamed: D_in_ram_r_0.2 (A), R_d_in_ram_r_0.2
unnamed: D_in_ram_w_0.2 (A), R_d_in_ram_w_0.2
unnamed: D_in_read_reg_en_0.2 (A), R_d_in_read_reg_en_0.2
unnamed: D_in_temp_w_0.2 (A), R_d_in_temp_w_0.2
unnamed: D_in_write_reg_en_0.2 (A), R_d_in_write_reg_en_0.2
unnamed: D_out_acc_r_0.1 (K), R_out_acc_r_0.1
unnamed 42: D_out_acc_w_0.1 (K), R_out_acc_w_0.1; also elsewhere on the board
unnamed: D_out_bus1_0.1 (K), R_out_bus1_0.1
unnamed: D_out_can_read_0.1 (K), R_out_can_read_0.1
unnamed: D_out_can_write_0.1 (K), R_out_can_write_0.1
unnamed: D_out_clk_internal_0.1 (K), R_out_clk_internal_0.1
unnamed: D_out_clkc_0.1 (K), R_out_clkc_0.1
unnamed: D_out_clkr_0.1 (K), R_out_clkr_0.1
unnamed: D_out_clkw_0.1 (K), R_out_clkw_0.1
unnamed: D_out_flags_C_out_0.1 (K), R_out_flags_C_out_0.1
unnamed: D_out_flags_eq_0.1 (K), R_out_flags_eq_0.1
unnamed: D_out_flags_gt_0.1 (K), R_out_flags_gt_0.1
unnamed: D_out_flags_w_0.1 (K), R_out_flags_w_0.1
unnamed: D_out_flags_z_0.1 (K), R_out_flags_z_0.1
unnamed: D_out_iar_r_0.1 (K), R_out_iar_r_0.1
unnamed: D_out_iar_w_0.1 (K), R_out_iar_w_0.1
unnamed: D_out_ir_w_0.1 (K), R_out_ir_w_0.1
unnamed: D_out_is_bus1_w_0.1 (K), R_out_is_bus1_w_0.1
unnamed: D_out_r0_r_0.1 (K), R_out_r0_r_0.1
unnamed: D_out_r0_w_0.1 (K), R_out_r0_w_0.1
unnamed: D_out_r1_r_0.1 (K), R_out_r1_r_0.1
unnamed: D_out_r1_w_0.1 (K), R_out_r1_w_0.1
unnamed: D_out_r2_r_0.1 (K), R_out_r2_r_0.1
unnamed: D_out_r2_w_0.1 (K), R_out_r2_w_0.1
unnamed: D_out_r3_r_0.1 (K), R_out_r3_r_0.1
unnamed: D_out_r3_w_0.1 (K), R_out_r3_w_0.1
unnamed: D_out_ram_a_w_0.1 (K), R_out_ram_a_w_0.1
unnamed: D_out_ram_r_0.1 (K), R_out_ram_r_0.1
unnamed: D_out_ram_w_0.1 (K), R_out_ram_w_0.1
unnamed: D_out_s1_0.1 (K), R_out_s1_0.1
unnamed: D_out_s2_0.1 (K), R_out_s2_0.1
unnamed: D_out_s3_0.1 (K), R_out_s3_0.1
unnamed: D_out_s4_0.1 (K), R_out_s4_0.1
unnamed: D_out_s5_0.1 (K), R_out_s5_0.1
unnamed: D_out_s6_0.1 (K), R_out_s6_0.1
unnamed: D_out_sysbus_0.1 (K), R_out_sysbus_0.1
unnamed: D_out_sysbus_1.1 (K), R_out_sysbus_1.1
unnamed: D_out_sysbus_2.1 (K), R_out_sysbus_2.1
unnamed: D_out_sysbus_3.1 (K), R_out_sysbus_3.1
unnamed: D_out_sysbus_4.1 (K), R_out_sysbus_4.1
unnamed: D_out_sysbus_5.1 (K), R_out_sysbus_5.1
unnamed: D_out_sysbus_6.1 (K), R_out_sysbus_6.1
unnamed: D_out_sysbus_7.1 (K), R_out_sysbus_7.1
unnamed: D_out_temp_w_0.1 (K), R_out_temp_w_0.1
unnamed: D_vcc_0.1 (K), R_vcc_0.1
unnamed: F_pwr_0.1, J_pwr_0.1 (VBUS)
unnamed: F_pwr_0.2, SW_pwr_0.1 (A)
unnamed: JP_SPI_Direct_PRG_0.1 (A), R_PROG_B_0.2
unnamed: J_FPGA_B_0.10, J_FPGA_B_0.19, J_FPGA_B_0.25, J_FPGA_B_1.1, J_FPGA_B_1.18, J_FPGA_B_1.27, J_FPGA_B_2.1, J_FPGA_B_2.10, J_FPGA_B_2.19, J_FPGA_B_2.25, J_FPGA_B_3.11, J_FPGA_B_3.19, J_FPGA_B_3.27
unnamed: P_JTAG_FPGA_0.4 (TMS), R_JTAG_TMS_0.1
unnamed: P_JTAG_FPGA_0.6 (TCK), R_JTAG_TCK_0.1
unnamed: P_JTAG_FPGA_0.8 (TDO), R_JTAG_TDO_0.1
unnamed: P_JTAG_FPGA_0.10 (TDI), R_JTAG_TDI_0.1
unnamed: R__eeprom_dq1_0.2, U_eeprom_0.2 (DQ1)
unnamed: R_clk_oe_0.2, X_clk_0.1 (EN)
unnamed: R_eeprom_hold_0.1, U_eeprom_0.7 (HOLD#)
unnamed: R_eeprom_w_0.2, U_eeprom_0.3 (W#)
unnamed: SW_pwr_0.2 (B), U_pwr_aux_0.3 (VI), U_pwr_vcc_0.3 (VI), U_pwr_vcc_core_0.3 (VI)
P1: JP_SPI_Direct_PRG_0.2 (B), J_FPGA_B_3.1, J_PROG_B_0.1, U_FPGA_0.1 (PROG_B)
P2: D_in_write_reg_en_0.1 (K), J_FPGA_B_3.2, R_in_write_reg_en_0.1, SW_in_write_reg_en_0.2 (B), U_FPGA_0.2 (IO_L01P_3)
P3: D_out_can_write_0.2 (A), J_FPGA_B_3.3, U_FPGA_0.3 (IO_L01N_3)
P4: D_in_bus1_one_0.1 (K), D_in_bus1_ps_0.2 (A), J_FPGA_B_3.4, R_in_bus1_0.1, SW_in_bus1_0.2 (B), U_FPGA_0.4 (IO_L02P_3)
P5: D_out_is_bus1_w_0.2 (A), J_FPGA_B_3.5, U_FPGA_0.5 (IO_L02N_3_VREF)
P6: D_in_is_bus1_w_0.1 (K), J_FPGA_B_3.6, R_in_is_bus1_w_0.1, SW_in_is_bus1_w_0.2 (B), U_FPGA_0.6 (IP_2_3)
P7: D_in_manual_input_r_0.1 (K), J_FPGA_B_3.7, R_in_manual_input_r_0.1, SW_read_register_0.1, U_FPGA_0.7 (IO_L03P_3)
P8: D_in_r3_r_0.1 (K), J_FPGA_B_3.8, R_in_r3_r_0.1, SW_read_register_0.12, U_FPGA_0.8 (IO_L03N_3)
P10: D_in_r2_r_0.1 (K), J_FPGA_B_3.10, R_in_r2_r_0.1, SW_read_register_0.11, U_FPGA_0.10 (IO_11_3)
P12: D_in_r1_r_0.1 (K), J_FPGA_B_3.12, R_in_r1_r_0.1, SW_read_register_0.10, U_FPGA_0.12 (IP_6_3_VREF)
P14: D_in_r0_r_0.1 (K), J_FPGA_B_3.14, R_in_r0_r_0.1, SW_read_register_0.9, U_FPGA_0.14 (IO_L04P_3_LHCLK0)
P15: D_in_ram_r_0.1 (K), J_FPGA_B_3.15, R_in_ram_r_0.1, SW_read_register_0.8, U_FPGA_0.15 (IO_L04N_3_LHCLK1)
P16: D_in_acc_r_0.1 (K), J_FPGA_B_3.16, R_in_acc_r_0.1, SW_read_register_0.7, U_FPGA_0.16 (IO_L05P_3_LHCLK2)
P17: D_in_ir_r_0.1 (K), J_FPGA_B_3.17, R_in_ir_r_0.1, SW_read_register_0.6, U_FPGA_0.17 (IO_L05N_3_LHCLK3)
P18: D_in_iar_r_0.1 (K), J_FPGA_B_3.18, R_in_iar_r_0.1, SW_read_register_0.5, U_FPGA_0.18 (IP_3_3)
P20: D_in_read_reg_en_0.1 (K), J_FPGA_B_3.20, R_in_read_reg_en_0.1, SW_in_read_reg_en_0.2 (B), U_FPGA_0.20 (IO_L06P_3_LHCLK4)
P21: D_out_can_read_0.2 (A), J_FPGA_B_3.21, U_FPGA_0.21 (IO_L06N_3_LHCLK5)
P22: D_out_flags_z_0.2 (A), J_FPGA_B_3.22, U_FPGA_0.22 (IO_L07P_3_LHCLK6)
P23: D_out_flags_eq_0.2 (A), J_FPGA_B_3.23, U_FPGA_0.23 (IO_L07N_3_LHCLK7)
P24: J_FPGA_B_3.24, R_reset_0.2, SW_reset_0.1, U_FPGA_0.24 (IP_4_3)
P25: D_out_flags_gt_0.2 (A), J_FPGA_B_3.25, U_FPGA_0.25 (IO_L08P_3)
P26: D_out_flags_C_out_0.2 (A), J_FPGA_B_3.26, U_FPGA_0.26 (IO_L08N_3)
P29: J_FPGA_B_3.29, J_P29_0.1, U_FPGA_0.29 (IO_12_3)
P31: J_FPGA_B_3.31, J_P31_0.1, U_FPGA_0.31 (IP_1_3_VREF)
P32: D_out_sysbus_0.2 (A), J_FPGA_B_3.32, U_FPGA_0.32 (IO_L09P_3)
P33: D_out_sysbus_1.2 (A), J_FPGA_B_3.33, U_FPGA_0.33 (IO_L09N_3)
P34: D_out_sysbus_2.2 (A), J_FPGA_B_3.34, U_FPGA_0.34 (IO_L10P_3)
P35: D_out_sysbus_3.2 (A), J_FPGA_B_3.35, U_FPGA_0.35 (IO_L10N_3)
P36: J_FPGA_B_3.36, J_P36_0.1, U_FPGA_0.36 (IP_5_3)
P38: J_FPGA_B_2.2, R_in_manual_input_o_0.1, SW_in_manual_input_o_0.2 (B), U_FPGA_0.38 (IP_2_2)
P39: J_FPGA_B_2.3, P_JTAG_FLASH_0.4 (TMS), R_eeprom_s_0.2, U_FPGA_0.39 (IO_L01P_2_CSOB), U_eeprom_0.1 (S#)
P41: J_FPGA_B_2.5, R_in_manual_input_o_1.1, SW_in_manual_input_o_1.2 (B), U_FPGA_0.41 (IP_3_2)
P44: J_FPGA_B_2.8, P_JTAG_FLASH_0.10 (TDI), U_FPGA_0.44 (IO_L02N_2_MOSI), U_eeprom_0.5 (DQ0)
P47: J_FPGA_B_2.11, R_in_manual_input_o_2.1, SW_in_manual_input_o_2.2 (B), U_FPGA_0.47 (IP_L03P_2)
P48: J_FPGA_B_2.12, J_P48_0.1, U_FPGA_0.48 (IP_L03N_2_VREF_2)
P50: D_out_sysbus_6.2 (A), J_FPGA_B_2.14, U_FPGA_0.50 (IO_L04P_2_GCLK12)
P51: D_out_sysbus_7.2 (A), J_FPGA_B_2.15, U_FPGA_0.51 (IO_L04N_2_GCLK13)
P52: J_FPGA_B_2.16, J_OUT_USART1_TX_0.1, U_FPGA_0.52 (IO_1_2)
P53: J_FPGA_B_2.17, U_FPGA_0.53 (IO_L05P_2_GCLK14)
P54: J_FPGA_B_2.18, R_in_manual_input_o_3.1, SW_in_manual_input_o_3.2 (B), U_FPGA_0.54 (IO_L05N_2_GCLK15)
P56: J_FPGA_B_2.20, J_clk_0.1, R_clk_out_0.2, U_FPGA_0.56 (IP_L06P_2_GCLK0)
P58: J_FPGA_B_2.22, R_in_manual_input_o_4.1, SW_in_manual_input_o_4.2 (B), U_FPGA_0.58 (IO_L07P_2_GCLK2)
P59: J_FPGA_B_2.23, R_in_manual_input_o_5.1, SW_in_manual_input_o_5.2 (B), U_FPGA_0.59 (IO_L07N_2_GCLK3)
P66: J_FPGA_B_2.30, R_in_manual_input_o_6.1, SW_in_manual_input_o_6.2 (B), U_FPGA_0.66 (IP_1_2_VREF)
P67: J_FPGA_B_2.31, R_VS_2.1, U_FPGA_0.67 (IO_L09P_2_VS2)
P68: J_FPGA_B_2.32, R_VS_1.1, U_FPGA_0.68 (IO_L09N_2_VS1)
P69: J_FPGA_B_2.33, R_in_manual_input_o_7.1, SW_in_manual_input_o_7.2 (B), U_FPGA_0.69 (IP_4_2)
P70: J_FPGA_B_2.34, R_VS_0.1, U_FPGA_0.70 (IO_L10P_2_VS0)
P74: D_out_s6_0.2 (A), J_FPGA_B_1.2, U_FPGA_0.74 (IO_L01P_1)
P75: D_out_s5_0.2 (A), J_FPGA_B_1.3, U_FPGA_0.75 (IO_L01N_1)
P76: D_out_s4_0.2 (A), J_FPGA_B_1.4, U_FPGA_0.76 (IO_L02P_1)
P77: D_out_s3_0.2 (A), J_FPGA_B_1.5, U_FPGA_0.77 (IO_L02N_1)
P78: J_FPGA_B_1.6, J_P78_0.1, U_FPGA_0.78 (IP_1_1)
P81: D_out_s2_0.2 (A), J_FPGA_B_1.9, U_FPGA_0.81 (IO_L03P_1)
P82: D_out_s1_0.2 (A), J_FPGA_B_1.10, U_FPGA_0.82 (IO_L03N_1)
P83: D_out_clkw_0.2 (A), J_FPGA_B_1.11, U_FPGA_0.83 (IO_2_1_VREF)
P84: J_FPGA_B_1.12, J_P84_0.1, U_FPGA_0.84 (IP_2_1)
P85: D_out_clkr_0.2 (A), J_FPGA_B_1.13, U_FPGA_0.85 (IO_L04P_1_RHCLK0)
P86: D_out_clkc_0.2 (A), J_FPGA_B_1.14, U_FPGA_0.86 (IO_L04N_1_RHCLK1)
P87: D_in_is_clk_manual_0.1 (K), J_FPGA_B_1.15, R_in_is_clk_manual_0.1, U1_clk_select_0.6 (P5), U_FPGA_0.87 (IO_L05P_1_RHCLK2)
P88: D_in_is_clk_low_0.1 (K), J_FPGA_B_1.16, R_in_is_clk_low_0.1, U1_clk_select_0.5 (P4), U_FPGA_0.88 (IO_L05N_1_RHCLK3)
P89: D_in_is_clk_high_0.1 (K), J_FPGA_B_1.17, R_in_is_clk_high_0.1, U1_clk_select_0.4 (P3), U_FPGA_0.89 (IP_3_1)
P91: D_in_is_clk_external_0.1 (K), J_FPGA_B_1.19, R_in_is_clk_external_0.1, U1_clk_select_0.3 (P2), U_FPGA_0.91 (IO_L06P_1_RHCLK4)
P92: D_in_is_clk_veryhigh_0.1 (K), J_FPGA_B_1.20, R_in_is_clk_veryhigh_0.1, U1_clk_select_0.2 (P1), U_FPGA_0.92 (IO_L06N_1_RHCLK5)
P93: D_out_clk_internal_0.2 (A), J_FPGA_B_1.21, U_FPGA_0.93 (IO_L07P_1_RHCLK6)
P94: D_out_iar_w_0.2 (A), J_FPGA_B_1.22, U_FPGA_0.94 (IO_L07N_1_RHCLK7)
P95: D_in_clk_manual_0.1 (K), J_FPGA_B_1.23, R_in_clk_manual_0.1, SW_in_clk_manual_0.1, U_FPGA_0.95 (IP_6_1_VREF)
P96: D_out_acc_w_0.2 (A), J_FPGA_B_1.24, U_FPGA_0.96 (IO_L08P_1)
P97: D_out_ram_w_0.2 (A), J_FPGA_B_1.25, U_FPGA_0.97 (IO_L08N_1)
P98: D_out_ir_w_0.2 (A), J_FPGA_B_1.26, U_FPGA_0.98 (IO_1_1)
P101: J_FPGA_B_1.29, J_P101_0.1, U_FPGA_0.101 (IP_4_1)
P103: D_out_temp_w_0.2 (A), J_FPGA_B_1.31, U_FPGA_0.103 (IO_L09P_1)
P104: D_out_ram_a_w_0.2 (A), J_FPGA_B_1.32, U_FPGA_0.104 (IO_L09N_1)
P105: D_out_flags_w_0.2 (A), J_FPGA_B_1.33, U_FPGA_0.105 (IO_L10P_1)
P106: D_out_r0_w_0.2 (A), J_FPGA_B_1.34, U_FPGA_0.106 (IO_L10N_1)
P107: J_FPGA_B_1.35, J_P107_0.1, U_FPGA_0.107 (IP_5_1)
P108: J_FPGA_B_1.36, J_TMS_0.1, R_JTAG_TMS_0.2, U_FPGA_0.108 (TMS)
P109: J_FPGA_B_0.1, J_TDO_0.1, R_JTAG_TDO_0.2, U_FPGA_0.109 (TDO)
P110: J_FPGA_B_0.2, J_TCK_0.1, R_JTAG_TCK_0.2, U_FPGA_0.110 (TCK)
P111: J_FPGA_B_0.3, J_P111_0.1, U_FPGA_0.111 (IP_1_0)
P112: D_out_r1_w_0.2 (A), J_FPGA_B_0.4, U_FPGA_0.112 (IO_L01P_0)
P113: D_out_r2_w_0.2 (A), J_FPGA_B_0.5, U_FPGA_0.113 (IO_L01N_0)
P114: J_FPGA_B_0.6, J_P114_0.1, U_FPGA_0.114 (IP_2_0)
P116: D_out_r3_w_0.2 (A), J_FPGA_B_0.8, U_FPGA_0.116 (IO_L02P_0)
P117: D_in_r3_w_0.1 (K), J_FPGA_B_0.9, R_in_r3_w_0.1, SW_in_r3_w_0.5 (B), U_FPGA_0.117 (IO_L02N_0)
P119: D_in_r2_w_0.1 (K), J_FPGA_B_0.11, R_in_r2_w_0.1, SW_in_r2_w_0.5 (B), U_FPGA_0.119 (IP_L03P_0)
P120: D_in_r1_w_0.1 (K), J_FPGA_B_0.12, R_in_r1_w_0.1, SW_in_r1_w_0.5 (B), U_FPGA_0.120 (IP_L03N_0)
P122: D_in_r0_w_0.1 (K), J_FPGA_B_0.14, R_in_r0_w_0.1, SW_in_r0_w_0.5 (B), U_FPGA_0.122 (IO_L04P_0_GCLK4)
P123: D_in_temp_w_0.1 (K), J_FPGA_B_0.15, R_in_temp_w_0.1, SW_in_temp_w_0.5 (B), U_FPGA_0.123 (IO_L04N_0_GCLK5)
P124: D_out_r3_r_0.2 (A), J_FPGA_B_0.16, U_FPGA_0.124 (IO_2_0_VREF)
P125: D_out_r2_r_0.2 (A), J_FPGA_B_0.17, U_FPGA_0.125 (IO_L05P_0_GCLK6)
P126: D_out_r1_r_0.2 (A), J_FPGA_B_0.18, U_FPGA_0.126 (IO_L05N_0_GCLK7)
P128: J_FPGA_B_0.20, J_P128_0.1, U_FPGA_0.128 (IP_L06P_0_GCLK8)
P129: J_FPGA_B_0.21, J_P129_0.1, U_FPGA_0.129 (IP_L06N_0_GCLK9)
P130: D_out_r0_r_0.2 (A), J_FPGA_B_0.22, U_FPGA_0.130 (IO_L07P_0_GCLK10)
P131: D_out_bus1_0.2 (A), J_FPGA_B_0.23, U_FPGA_0.131 (IO_L07N_0_GCLK11)
P132: D_out_ram_r_0.2 (A), J_FPGA_B_0.24, U_FPGA_0.132 (IO_1_0)
P134: D_out_acc_r_0.2 (A), J_FPGA_B_0.26, U_FPGA_0.134 (IO_L08P_0)
P135: D_out_iar_r_0.2 (A), J_FPGA_B_0.27, U_FPGA_0.135 (IO_L08N_0_VREF_0)
P136: D_in_ram_w_0.1 (K), J_FPGA_B_0.28, R_in_ram_w_0.1, SW_in_ram_w_0.5 (B), U_FPGA_0.136 (IP_3_0)
P139: D_in_ram_a_w_0.1 (K), J_FPGA_B_0.31, R_in_ram_a_w_0.1, SW_in_ram_a_w_0.5 (B), U_FPGA_0.139 (IO_L09P_0)
P140: D_in_acc_w_0.1 (K), J_FPGA_B_0.32, R_in_acc_w_0.1, SW_in_acc_w_0.5 (B), U_FPGA_0.140 (IO_L09N_0)
P141: D_in_ir_w_0.1 (K), J_FPGA_B_0.33, R_in_ir_w_0.1, SW_in_ir_w_0.5 (B), U_FPGA_0.141 (IP_4_0)
P142: D_in_iar_w_0.1 (K), J_FPGA_B_0.34, R_in_iar_w_0.1, SW_in_iar_w_0.5 (B), U_FPGA_0.142 (IO_L10P_0)
P144: J_FPGA_B_0.36, J_TDI_0.1, R_JTAG_TDI_0.2, U_FPGA_0.144 (TDI)
VCC: C_clk_0.1, C_clk_1.1, C_eeprom_vcc_0.2, C_pwr_vcc_0.1, D_vcc_0.2 (A), J_FPGA_B_0.13, J_FPGA_B_1.7, J_FPGA_B_1.28, J_FPGA_B_1.30, J_FPGA_B_2.6, J_FPGA_B_2.13, J_FPGA_B_2.28, J_FPGA_B_2.29, J_FPGA_B_3.13, J_FPGA_B_3.28, J_FPGA_B_3.30, J_VCC_0.1, P_JTAG_FLASH_0.2 (VCC_ref), R_HSWAP_EN_0.2, R_M_0.2, R_VS_0.2, R_VS_1.2, R_VS_2.2, R_clk_oe_0.1, R_d_in_acc_r_0.1, R_d_in_acc_w_0.1, R_d_in_bus1_one_0.2, R_d_in_clk_manual_0.1, R_d_in_iar_r_0.1, R_d_in_iar_w_0.1, R_d_in_ir_r_0.1, R_d_in_ir_w_0.1, R_d_in_is_bus1_w_0.1, R_d_in_is_clk_external_0.1, R_d_in_is_clk_high_0.1, R_d_in_is_clk_low_0.1, R_d_in_is_clk_manual_0.1, R_d_in_is_clk_veryhigh_0.1, R_d_in_manual_input_r_0.1, R_d_in_none_r_0.1, R_d_in_r0_r_0.1, R_d_in_r0_w_0.1, R_d_in_r1_r_0.1, R_d_in_r1_w_0.1, R_d_in_r2_r_0.1, R_d_in_r2_w_0.1, R_d_in_r3_r_0.1, R_d_in_r3_w_0.1, R_d_in_ram_a_w_0.1, R_d_in_ram_r_0.1, R_d_in_ram_w_0.1, R_d_in_read_reg_en_0.1, R_d_in_temp_w_0.1, R_d_in_write_reg_en_0.1, R_eeprom_hold_0.2, R_eeprom_s_0.1, R_eeprom_spi_clk_pullup_0.2, R_eeprom_w_0.1, R_in_acc_r_0.2, R_in_acc_w_0.2, R_in_bus1_0.2, R_in_clk_manual_0.2, R_in_iar_r_0.2, R_in_iar_w_0.2, R_in_ir_r_0.2, R_in_ir_w_0.2, R_in_is_bus1_w_0.2, R_in_is_clk_external_0.2, R_in_is_clk_high_0.2, R_in_is_clk_low_0.2, R_in_is_clk_manual_0.2, R_in_is_clk_veryhigh_0.2, R_in_manual_input_o_0.2, R_in_manual_input_o_1.2, R_in_manual_input_o_2.2, R_in_manual_input_o_3.2, R_in_manual_input_o_4.2, R_in_manual_input_o_5.2, R_in_manual_input_o_6.2, R_in_manual_input_o_7.2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
VCC_aux: C_pwr_aux_0.1, C_pwr_aux_1.1, J_VCC_aux_0.1, P_JTAG_FPGA_0.2 (VCC_ref), U_FPGA_0.30 (VCCAUX1), U_FPGA_0.65 (VCCAUX2), U_FPGA_0.102 (VCCAUX3), U_FPGA_0.137 (VCCAUX4), U_pwr_aux_0.2 (VO)
VCC_core: C_pwr_vcc_core_0.1, C_pwr_vcc_core_1.1, J_FPGA_B_0.7, J_FPGA_B_1.8, J_FPGA_B_2.9, J_FPGA_B_3.9, J_VCC_core_0.1, U_FPGA_0.9 (VCCINT1), U_FPGA_0.45 (VCCINT2), U_FPGA_0.80 (VCCINT3), U_FPGA_0.115 (VCCINT4), U_pwr_vcc_core_0.2 (VO)

Notes on the sheet:
Flags
TODO: check connections
CPU Control
Stepper
TODO: Check pinout with particular switch pins
TODO:
Bus Input
Read Register
Write Register
Bus Data
Clock
1/Passthrough
TODO: Check connections
